	AREA reset,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R1,=2
	LDR R2,=3
	MOV R4, R1
	MOV R7, R2
	MOV R6,#0
	
UP CMP R1,R2
	BEQ GCD
	BCS DIV
	MOV R5,R1
	MOV R1,R2
	MOV R2,R5
	B DIV

DIV SUB R1,R2
	CMP R1,R2
	BCS DIV
	CMP R1,#0
	BEQ GCD
	B UP
	
	
GCD MOV R10, R2
	
	MUL R8,R4,R7
	
DIV1 SUB R8,R2
	ADD R6,#1
	CMP R8,R2
	BCS DIV1

ANS MOV R11,R6

STOP
	B STOP
	END