	AREA reset,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R7,=DST
	LDR R1,=55
	LDR R2,=11
UP CMP R1,R2
	BEQ GCD
	BCS DIV
	MOV R5,R1
	MOV R1,R2
	MOV R2,R5
	B DIV
	
GCD MOV R10,R2

DIV SUB R1,R2
	CMP R1,R2
	BCS DIV
	CMP R1,#0
	BEQ GCD
	B UP
	
	STR R10,[R7]
STOP
	B STOP
	AREA mydate,DATA,READWRITE
DST DCD 0x0
	END